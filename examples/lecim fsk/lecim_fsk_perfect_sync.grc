<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable_cc_decoder_def</key>
<param><key>id</key><value>cc_decoder</value></param>
<param><key>padding</key><value>False</value></param>
<param><key>k</key><value>7</value></param>
<param><key>state_end</key><value>-1</value></param>
<param><key>framebits</key><value>nBlock*9*8</value></param>
<param><key>ndim</key><value>0</value></param>
<param><key>polys</key><value>cc_poly</value></param>
<param><key>rate</key><value>2</value></param>
<param><key>state_start</key><value>0</value></param>
<param><key>mode</key><value>fec.CC_TERMINATED</value></param>
</block>
<block>
<key>variable_cc_encoder_def</key>
<param><key>id</key><value>cc_encoder</value></param>
<param><key>padding</key><value>False</value></param>
<param><key>k</key><value>7</value></param>
<param><key>framebits</key><value>nBlock*9*8</value></param>
<param><key>ndim</key><value>0</value></param>
<param><key>polys</key><value>cc_poly</value></param>
<param><key>rate</key><value>2</value></param>
<param><key>state_start</key><value>0</value></param>
<param><key>mode</key><value>fec.CC_TERMINATED</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cc_poly</value></param>
<param><key>value</key><value>[121,91]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq_dev</value></param>
<param><key>value</key><value>9375</value></param>
</block>
<block>
<key>variable_tag_object</key>
<param><key>id</key><value>len_tag_var</value></param>
<param><key>key</key><value>pmt.intern("packet_len")</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>src</key><value>pmt.intern("src")</value></param>
<param><key>value</key><value>pmt.from_long(pdu_size*8)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>len_tag_var</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>"packet_len"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nBlock</value></param>
<param><key>value</key><value>int(ceil((8*pdu_size+6)/(lpwan.fsk_lecim_constants.nPsdu/2.0)))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>noise</value></param>
<param><key>value</key><value>(np.sqrt(1/10**(ebn0_db/10.0))*1.0)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pad</value></param>
<param><key>value</key><value>int((nBlock*(lpwan.fsk_lecim_constants.nPsdu/2))-(8*pdu_size+6))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pdu_size</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>symbol_rate</value></param>
<param><key>value</key><value>37500</value></param>
</block>
<block>
<key>analog_random_source_x</key>
<param><key>id</key><value>analog_random_source_x_0_0</value></param>
<param><key>max</key><value>256</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_samps</key><value>pdu_size*8</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>/Users/victorguipont/Developpement-informatique/GNU-radio/sf1024</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0</value></param>
<param><key>file</key><value>/Users/victorguipont/Developpement-informatique/GNU-radio/pdu + pad</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_repack_bits_bb</key>
<param><key>id</key><value>blocks_repack_bits_bb_0_0</value></param>
<param><key>k</key><value>8</value></param>
<param><key>l</key><value>1</value></param>
<param><key>endianness</key><value>gr.GR_LSB_FIRST</value></param>
<param><key>len_tag_key</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_stream_to_tagged_stream</key>
<param><key>id</key><value>blocks_stream_to_tagged_stream_0_0</value></param>
<param><key>len_tag_key</key><value>packet_len</value></param>
<param><key>packet_len</key><value>pdu_size</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>digital_chunks_to_symbols_xx</key>
<param><key>id</key><value>digital_chunks_to_symbols_xx_0</value></param>
<param><key>dimension</key><value>1</value></param>
<param><key>in_type</key><value>byte</value></param>
<param><key>out_type</key><value>float</value></param>
<param><key>symbol_table</key><value>-1,1</value></param>
</block>
<block>
<key>digital_chunks_to_symbols_xx</key>
<param><key>id</key><value>digital_chunks_to_symbols_xx_0_0</value></param>
<param><key>dimension</key><value>2 if pfsk else 1</value></param>
<param><key>in_type</key><value>byte</value></param>
<param><key>out_type</key><value>float</value></param>
<param><key>symbol_table</key><value>[-1,0,0,-1,1,0,0,1] if pfsk else [-1,1]</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ebn0_db</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>3</value></param>
</block>
<block>
<key>fec_extended_tagged_decoder</key>
<param><key>id</key><value>fec_extended_tagged_decoder_0</value></param>
<param><key>decoder_list</key><value>cc_decoder</value></param>
<param><key>lentagname</key><value>packet_len</value></param>
<param><key>mtu</key><value>nBlock*9</value></param>
<param><key>puncpat</key><value>'11'</value></param>
</block>
<block>
<key>fec_extended_tagged_encoder</key>
<param><key>id</key><value>fec_extended_tagged_encoder</value></param>
<param><key>encoder_list</key><value>cc_encoder</value></param>
<param><key>lentagname</key><value>packet_len</value></param>
<param><key>mtu</key><value>nBlock*9</value></param>
<param><key>puncpat</key><value>'11'</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy as np</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0</value></param>
<param><key>import</key><value>import random as rnd</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0_0</value></param>
<param><key>import</key><value>from math import ceil</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_2</value></param>
<param><key>import</key><value>import lpwan</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_2</value></param>
<param><key>import</key><value>import pmt</value></param>
</block>
<block>
<key>lecim_fsk_zero_padding</key>
<param><key>id</key><value>lecim_fsk_zero_padding_0</value></param>
<param><key>len_tag_var</key><value>"packet_len"</value></param>
<param><key>pad</key><value>pad</value></param>
</block>
<block>
<key>lpwan_fsk_lecim_deinterleaver</key>
<param><key>id</key><value>lpwan_fsk_lecim_deinterleaver_0</value></param>
<param><key>len_tag</key><value>packet_len</value></param>
<param><key>nBlock</key><value>nBlock</value></param>
<param><key>phr</key><value>False</value></param>
</block>
<block>
<key>lpwan_fsk_lecim_demodulator_cb</key>
<param><key>id</key><value>lpwan_fsk_lecim_demodulator_cb_0</value></param>
<param><key>freq_dev</key><value>freq_dev</value></param>
<param><key>pfsk</key><value>pfsk</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>symbol_rate</key><value>symbol_rate</value></param>
</block>
<block>
<key>lpwan_fsk_lecim_despreading_bb</key>
<param><key>id</key><value>lpwan_fsk_lecim_despreading_bb_0</value></param>
<param><key>alternating</key><value>spreading_alternating</value></param>
<param><key>spreading</key><value>True</value></param>
<param><key>spreading_factor</key><value>spreading_factor</value></param>
</block>
<block>
<key>lpwan_fsk_lecim_interleaver</key>
<param><key>id</key><value>lpwan_fsk_lecim_interleaver_0</value></param>
<param><key>len_tag</key><value>packet_len</value></param>
<param><key>nBlock</key><value>nBlock</value></param>
<param><key>phr</key><value>False</value></param>
</block>
<block>
<key>lpwan_fsk_lecim_modulator_fc</key>
<param><key>id</key><value>lpwan_fsk_lecim_modulator_fc_0</value></param>
<param><key>freq_dev</key><value>freq_dev</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>symbol_rate</key><value>symbol_rate</value></param>
</block>
<block>
<key>lpwan_fsk_lecim_spreading_bb</key>
<param><key>id</key><value>lpwan_fsk_lecim_spreading_bb_0</value></param>
<param><key>alternating</key><value>spreading_alternating</value></param>
<param><key>spreading</key><value>True</value></param>
<param><key>spreading_factor</key><value>spreading_factor</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>pfsk</value></param>
<param><key>label</key><value>Position based FSK</value></param>
<param><key>value</key><value>False</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>spreading_alternating</value></param>
<param><key>label</key><value>Spreading alternating</value></param>
<param><key>value</key><value>False</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>spreading_factor</value></param>
<param><key>label</key><value>Spreading factor</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>sps</value></param>
<param><key>label</key><value>Sample per symbol</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>20</value></param>
</block>
<connection><source_block_id>analog_random_source_x_0_0</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repack_bits_bb_0_0</source_block_id><sink_block_id>lecim_fsk_zero_padding_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0_0</source_block_id><sink_block_id>blocks_repack_bits_bb_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_chunks_to_symbols_xx_0</source_block_id><sink_block_id>fec_extended_tagged_decoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_chunks_to_symbols_xx_0_0</source_block_id><sink_block_id>lpwan_fsk_lecim_modulator_fc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fec_extended_tagged_decoder_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fec_extended_tagged_encoder</source_block_id><sink_block_id>lpwan_fsk_lecim_interleaver_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lecim_fsk_zero_padding_0</source_block_id><sink_block_id>blocks_file_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lecim_fsk_zero_padding_0</source_block_id><sink_block_id>fec_extended_tagged_encoder</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_fsk_lecim_deinterleaver_0</source_block_id><sink_block_id>digital_chunks_to_symbols_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_fsk_lecim_demodulator_cb_0</source_block_id><sink_block_id>lpwan_fsk_lecim_despreading_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_fsk_lecim_despreading_bb_0</source_block_id><sink_block_id>lpwan_fsk_lecim_deinterleaver_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_fsk_lecim_interleaver_0</source_block_id><sink_block_id>lpwan_fsk_lecim_spreading_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_fsk_lecim_modulator_fc_0</source_block_id><sink_block_id>lpwan_fsk_lecim_demodulator_cb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_fsk_lecim_spreading_bb_0</source_block_id><sink_block_id>digital_chunks_to_symbols_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
