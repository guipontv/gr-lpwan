<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>phy</value></param>
<param><key>value</key><value>lpwan.fsk_lecim_phy.physical_layer(sps, index, band, preamble_len, fcs, data_whitening, pfsk, spreading, spreading_alternating, spreading_factor, pdu_len)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_0</value></param>
<param><key>value</key><value>12500</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_1</value></param>
<param><key>value</key><value>25000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_2</value></param>
<param><key>value</key><value>37500</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>band</value></param>
<param><key>label</key><value>Band 169Mhz</value></param>
<param><key>value</key><value>False</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_inputs</key><value>5</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0</value></param>
<param><key>delay</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0_0</value></param>
<param><key>delay</key><value>1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0_1</value></param>
<param><key>delay</key><value>2</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0_1_0</value></param>
<param><key>delay</key><value>3</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0_1_0_0</value></param>
<param><key>delay</key><value>4</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_1</value></param>
<param><key>delay</key><value>2*len(phy.preamble_mod)-4</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_stream_mux</key>
<param><key>id</key><value>blocks_stream_mux_1</value></param>
<param><key>lengths</key><value> len(phy.preamble_mod), 5000,  len(phy.preamble_mod), 5000,  len(phy.preamble_mod), 5000,  len(phy.preamble_mod), 5000,  len(phy.preamble_mod), 5000,  len(phy.preamble_mod), 5000,  len(phy.preamble_mod), 5000,  len(phy.preamble_mod), 5000,  len(phy.preamble_mod), 5000,  len(phy.preamble_mod), 5000</value></param>
<param><key>num_inputs</key><value>20</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_tag_debug</key>
<param><key>id</key><value>blocks_tag_debug_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_tag_gate</key>
<param><key>id</key><value>blocks_tag_gate_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>propagate_tags</key><value>True</value></param>
</block>
<block>
<key>blocks_tag_gate</key>
<param><key>id</key><value>blocks_tag_gate_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>propagate_tags</key><value>False</value></param>
</block>
<block>
<key>blocks_tag_gate</key>
<param><key>id</key><value>blocks_tag_gate_0_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>propagate_tags</key><value>False</value></param>
</block>
<block>
<key>blocks_tag_gate</key>
<param><key>id</key><value>blocks_tag_gate_0_2</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>propagate_tags</key><value>False</value></param>
</block>
<block>
<key>blocks_tag_gate</key>
<param><key>id</key><value>blocks_tag_gate_0_2_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>propagate_tags</key><value>False</value></param>
</block>
<block>
<key>blocks_tag_gate</key>
<param><key>id</key><value>blocks_tag_gate_0_2_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>propagate_tags</key><value>False</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>False</value></param>
<param><key>tags</key><value>[gr.tag_utils.python_to_tag((0, pmt.intern("start"), pmt.from_long(0)))]</value></param>
<param><key>vector</key><value>phy.preamble_mod</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>False</value></param>
<param><key>vector</key><value>np.zeros(5000)</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>data_whitening</value></param>
<param><key>label</key><value>Data whitening</value></param>
<param><key>value</key><value>False</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fcs</value></param>
<param><key>label</key><value>FCS</value></param>
<param><key>value</key><value>False</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy as np</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0</value></param>
<param><key>import</key><value>import pmt</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_1</value></param>
<param><key>import</key><value>import lpwan</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>index</value></param>
<param><key>label</key><value>Modulation index</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>lpwan_conj_multiply_delay_ccc</key>
<param><key>id</key><value>lpwan_conj_multiply_delay_ccc_0</value></param>
<param><key>delay</key><value>1</value></param>
</block>
<block>
<key>lpwan_conj_multiply_delay_ccc</key>
<param><key>id</key><value>lpwan_conj_multiply_delay_ccc_0_1</value></param>
<param><key>delay</key><value>2</value></param>
</block>
<block>
<key>lpwan_conj_multiply_delay_ccc</key>
<param><key>id</key><value>lpwan_conj_multiply_delay_ccc_0_2</value></param>
<param><key>delay</key><value>3</value></param>
</block>
<block>
<key>lpwan_conj_multiply_delay_ccc</key>
<param><key>id</key><value>lpwan_conj_multiply_delay_ccc_0_2_0</value></param>
<param><key>delay</key><value>4</value></param>
</block>
<block>
<key>lpwan_conj_multiply_delay_ccc</key>
<param><key>id</key><value>lpwan_conj_multiply_delay_ccc_0_2_0_0</value></param>
<param><key>delay</key><value>5</value></param>
</block>
<block>
<key>lpwan_fsk_lecim_correlation_filter</key>
<param><key>id</key><value>lpwan_fsk_lecim_correlation_filter_0</value></param>
<param><key>delay</key><value>1</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>preamble</key><value>phy.preamble_mod</value></param>
</block>
<block>
<key>lpwan_fsk_lecim_correlation_filter</key>
<param><key>id</key><value>lpwan_fsk_lecim_correlation_filter_0_0</value></param>
<param><key>delay</key><value>3</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>preamble</key><value>phy.preamble_mod</value></param>
</block>
<block>
<key>lpwan_fsk_lecim_correlation_filter</key>
<param><key>id</key><value>lpwan_fsk_lecim_correlation_filter_0_0_0</value></param>
<param><key>delay</key><value>4</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>preamble</key><value>phy.preamble_mod</value></param>
</block>
<block>
<key>lpwan_fsk_lecim_correlation_filter</key>
<param><key>id</key><value>lpwan_fsk_lecim_correlation_filter_0_0_0_0</value></param>
<param><key>delay</key><value>5</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>preamble</key><value>phy.preamble_mod</value></param>
</block>
<block>
<key>lpwan_fsk_lecim_correlation_filter</key>
<param><key>id</key><value>lpwan_fsk_lecim_correlation_filter_0_1</value></param>
<param><key>delay</key><value>2</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>preamble</key><value>phy.preamble_mod</value></param>
</block>
<block>
<key>lpwan_fsk_lecim_detector</key>
<param><key>id</key><value>lpwan_fsk_lecim_detector_0</value></param>
<param><key>delay</key><value>5</value></param>
<param><key>len_preamble</key><value>len(phy.preamble_mod)</value></param>
<param><key>threshold</key><value>0.99</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>pdu_len</value></param>
<param><key>label</key><value>PDU Length</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>28</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>pfsk</value></param>
<param><key>label</key><value>Position based FSK</value></param>
<param><key>value</key><value>False</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>preamble_len</value></param>
<param><key>label</key><value>Preamble Length</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>64</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>size</key><value>1024*3</value></param>
<param><key>srate</key><value>samp_rate_1*sps</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_TAG</value></param>
<param><key>tr_tag</key><value>"start"</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>5200</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_1</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate_1</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_TAG</value></param>
<param><key>tr_tag</key><value>"start"</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>resampling</value></param>
<param><key>label</key><value>resampling</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>spreading</value></param>
<param><key>label</key><value>Spreading</value></param>
<param><key>value</key><value>True</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>spreading_alternating</value></param>
<param><key>label</key><value>Spreading alternating</value></param>
<param><key>value</key><value>False</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>spreading_factor</value></param>
<param><key>label</key><value>Spreading factor</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>16</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>sps</value></param>
<param><key>label</key><value>Sample per symbol</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>2</value></param>
</block>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>blocks_tag_gate_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_delay_0_1</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_delay_0_1_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>blocks_delay_0_1_0_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>blocks_delay_1</source_block_id><sink_block_id>lpwan_fsk_lecim_detector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_mux_1</source_block_id><sink_block_id>blocks_delay_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_mux_1</source_block_id><sink_block_id>lpwan_conj_multiply_delay_ccc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_mux_1</source_block_id><sink_block_id>lpwan_conj_multiply_delay_ccc_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_mux_1</source_block_id><sink_block_id>lpwan_conj_multiply_delay_ccc_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_mux_1</source_block_id><sink_block_id>lpwan_conj_multiply_delay_ccc_0_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_mux_1</source_block_id><sink_block_id>lpwan_conj_multiply_delay_ccc_0_2_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tag_gate_0</source_block_id><sink_block_id>lpwan_fsk_lecim_correlation_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tag_gate_0_0</source_block_id><sink_block_id>lpwan_fsk_lecim_detector_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_tag_gate_0_1</source_block_id><sink_block_id>lpwan_fsk_lecim_correlation_filter_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tag_gate_0_2</source_block_id><sink_block_id>lpwan_fsk_lecim_correlation_filter_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tag_gate_0_2_0</source_block_id><sink_block_id>lpwan_fsk_lecim_correlation_filter_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tag_gate_0_2_0_0</source_block_id><sink_block_id>lpwan_fsk_lecim_correlation_filter_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0</source_block_id><sink_block_id>blocks_stream_mux_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0</source_block_id><sink_block_id>blocks_stream_mux_1</sink_block_id><source_key>0</source_key><sink_key>10</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0</source_block_id><sink_block_id>blocks_stream_mux_1</sink_block_id><source_key>0</source_key><sink_key>12</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0</source_block_id><sink_block_id>blocks_stream_mux_1</sink_block_id><source_key>0</source_key><sink_key>14</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0</source_block_id><sink_block_id>blocks_stream_mux_1</sink_block_id><source_key>0</source_key><sink_key>16</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0</source_block_id><sink_block_id>blocks_stream_mux_1</sink_block_id><source_key>0</source_key><sink_key>18</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0</source_block_id><sink_block_id>blocks_stream_mux_1</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0</source_block_id><sink_block_id>blocks_stream_mux_1</sink_block_id><source_key>0</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0</source_block_id><sink_block_id>blocks_stream_mux_1</sink_block_id><source_key>0</source_key><sink_key>6</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0</source_block_id><sink_block_id>blocks_stream_mux_1</sink_block_id><source_key>0</source_key><sink_key>8</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0_0</source_block_id><sink_block_id>blocks_stream_mux_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0_0</source_block_id><sink_block_id>blocks_stream_mux_1</sink_block_id><source_key>0</source_key><sink_key>11</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0_0</source_block_id><sink_block_id>blocks_stream_mux_1</sink_block_id><source_key>0</source_key><sink_key>13</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0_0</source_block_id><sink_block_id>blocks_stream_mux_1</sink_block_id><source_key>0</source_key><sink_key>15</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0_0</source_block_id><sink_block_id>blocks_stream_mux_1</sink_block_id><source_key>0</source_key><sink_key>17</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0_0</source_block_id><sink_block_id>blocks_stream_mux_1</sink_block_id><source_key>0</source_key><sink_key>19</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0_0</source_block_id><sink_block_id>blocks_stream_mux_1</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0_0</source_block_id><sink_block_id>blocks_stream_mux_1</sink_block_id><source_key>0</source_key><sink_key>5</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0_0</source_block_id><sink_block_id>blocks_stream_mux_1</sink_block_id><source_key>0</source_key><sink_key>7</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0_0</source_block_id><sink_block_id>blocks_stream_mux_1</sink_block_id><source_key>0</source_key><sink_key>9</sink_key></connection>
<connection><source_block_id>lpwan_conj_multiply_delay_ccc_0</source_block_id><sink_block_id>blocks_tag_gate_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_conj_multiply_delay_ccc_0_1</source_block_id><sink_block_id>blocks_tag_gate_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_conj_multiply_delay_ccc_0_2</source_block_id><sink_block_id>blocks_tag_gate_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_conj_multiply_delay_ccc_0_2_0</source_block_id><sink_block_id>blocks_tag_gate_0_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_conj_multiply_delay_ccc_0_2_0_0</source_block_id><sink_block_id>blocks_tag_gate_0_2_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_fsk_lecim_correlation_filter_0</source_block_id><sink_block_id>blocks_delay_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_fsk_lecim_correlation_filter_0_0</source_block_id><sink_block_id>blocks_delay_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_fsk_lecim_correlation_filter_0_0_0</source_block_id><sink_block_id>blocks_delay_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_fsk_lecim_correlation_filter_0_0_0_0</source_block_id><sink_block_id>blocks_delay_0_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_fsk_lecim_correlation_filter_0_1</source_block_id><sink_block_id>blocks_delay_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_fsk_lecim_detector_0</source_block_id><sink_block_id>blocks_tag_debug_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_fsk_lecim_detector_0</source_block_id><sink_block_id>qtgui_time_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
