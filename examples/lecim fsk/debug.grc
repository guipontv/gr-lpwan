<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>variable_cc_decoder_def</key>
<param><key>id</key><value>cc_decoder_PDU</value></param>
<param><key>padding</key><value>False</value></param>
<param><key>k</key><value>7</value></param>
<param><key>state_end</key><value>-1</value></param>
<param><key>framebits</key><value>phy.n_block*9*8</value></param>
<param><key>ndim</key><value>0</value></param>
<param><key>polys</key><value>cc_poly</value></param>
<param><key>rate</key><value>2</value></param>
<param><key>state_start</key><value>0</value></param>
<param><key>mode</key><value>fec.CC_TAILBITING</value></param>
</block>
<block>
<key>variable_cc_encoder_def</key>
<param><key>id</key><value>cc_encoder_PDU</value></param>
<param><key>padding</key><value>False</value></param>
<param><key>k</key><value>7</value></param>
<param><key>framebits</key><value>phy.n_block*9*8</value></param>
<param><key>ndim</key><value>0</value></param>
<param><key>polys</key><value>cc_poly</value></param>
<param><key>rate</key><value>2</value></param>
<param><key>state_start</key><value>0</value></param>
<param><key>mode</key><value>fec.CC_TAILBITING</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cc_poly</value></param>
<param><key>value</key><value>[121,91]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>len_tag_var</value></param>
<param><key>value</key><value>"packet_len"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>phy</value></param>
<param><key>value</key><value>lpwan.fsk_lecim_phy.physical_layer(sps, index, band, preamble_len, fcs, data_whitening, pfsk, spreading, spreading_alternating, spreading_factor, pdu_len)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_0</value></param>
<param><key>value</key><value>12500</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_1</value></param>
<param><key>value</key><value>25000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_2</value></param>
<param><key>value</key><value>37500</value></param>
</block>
<block>
<key>analog_random_source_x</key>
<param><key>id</key><value>analog_random_source_x_0</value></param>
<param><key>max</key><value>255</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_samps</key><value>26*512</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>20000</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate_1*sps</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>1000</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate_1*sps</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>band</value></param>
<param><key>label</key><value>Band 169Mhz</value></param>
<param><key>value</key><value>False</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>/Users/victorguipont/Developpement-informatique/GNU-radio/out</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/Users/victorguipont/Developpement-informatique/GNU-radio/sf1024 copie 3</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/Users/victorguipont/Developpement-informatique/GNU-radio/source1</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0_0</value></param>
<param><key>file</key><value>/Users/victorguipont/Developpement-informatique/GNU-radio/source2</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/Users/victorguipont/Developpement-informatique/GNU-radio/source3</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_1</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_2</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_or_xx</key>
<param><key>id</key><value>blocks_or_xx_0</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_or_xx</key>
<param><key>id</key><value>blocks_or_xx_0_0</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_1</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_repack_bits_bb</key>
<param><key>id</key><value>blocks_repack_bits_bb_0</value></param>
<param><key>k</key><value>1</value></param>
<param><key>l</key><value>8</value></param>
<param><key>endianness</key><value>gr.GR_LSB_FIRST</value></param>
<param><key>len_tag_key</key><value>pdu_len</value></param>
</block>
<block>
<key>blocks_repack_bits_bb</key>
<param><key>id</key><value>blocks_repack_bits_bb_0_0_0</value></param>
<param><key>k</key><value>8</value></param>
<param><key>l</key><value>1</value></param>
<param><key>endianness</key><value>gr.GR_LSB_FIRST</value></param>
<param><key>len_tag_key</key><value>len_tag_var</value></param>
<param><key>align_output</key><value>True</value></param>
</block>
<block>
<key>blocks_stream_mux</key>
<param><key>id</key><value>blocks_stream_mux_0</value></param>
<param><key>lengths</key><value>1, 1, 26</value></param>
<param><key>num_inputs</key><value>3</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_stream_mux</key>
<param><key>id</key><value>blocks_stream_mux_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>lengths</key><value>282,6</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_stream_to_tagged_stream</key>
<param><key>id</key><value>blocks_stream_to_tagged_stream_0</value></param>
<param><key>len_tag_key</key><value>"packet_len"</value></param>
<param><key>packet_len</key><value>28</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_tag_debug</key>
<param><key>id</key><value>blocks_tag_debug_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_tag_gate</key>
<param><key>id</key><value>blocks_tag_gate_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>propagate_tags</key><value>False</value></param>
</block>
<block>
<key>blocks_tagged_stream_to_pdu</key>
<param><key>id</key><value>blocks_tagged_stream_to_pdu_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_tagged_stream_to_pdu</key>
<param><key>id</key><value>blocks_tagged_stream_to_pdu_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>pdu_len</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>tags</key><value>[gr.tag_utils.python_to_tag((0, pmt.intern("pdu_len"), pmt.from_long(pdu_len)))]</value></param>
<param><key>vector</key><value>[0 for i in range(576*spreading_factor) ]</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>tags</key><value>[gr.tag_utils.python_to_tag((0, pmt.intern("packet_len"), pmt.from_long(576)))]</value></param>
<param><key>vector</key><value>[0 for i in range(576*spreading_factor) ]</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vector</key><value>(0, 0, 0, 0, 0, 0)</value></param>
</block>
<block>
<key>blocks_xor_xx</key>
<param><key>id</key><value>blocks_xor_xx_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>data_whitening</value></param>
<param><key>label</key><value>Data whitening</value></param>
<param><key>value</key><value>False</value></param>
</block>
<block>
<key>digital_chunks_to_symbols_xx</key>
<param><key>id</key><value>digital_chunks_to_symbols_xx_0_0</value></param>
<param><key>dimension</key><value>1</value></param>
<param><key>in_type</key><value>byte</value></param>
<param><key>out_type</key><value>float</value></param>
<param><key>symbol_table</key><value>[-1,1]</value></param>
</block>
<block>
<key>digital_chunks_to_symbols_xx</key>
<param><key>id</key><value>digital_chunks_to_symbols_xx_0_0_0</value></param>
<param><key>dimension</key><value>1</value></param>
<param><key>in_type</key><value>byte</value></param>
<param><key>out_type</key><value>float</value></param>
<param><key>symbol_table</key><value>-1,1</value></param>
</block>
<block>
<key>digital_crc32_async_bb</key>
<param><key>id</key><value>digital_crc32_async_bb_1</value></param>
<param><key>check</key><value>True</value></param>
</block>
<block>
<key>digital_crc32_bb</key>
<param><key>id</key><value>digital_crc32_bb_0</value></param>
<param><key>lengthtagname</key><value>"packet_len"</value></param>
<param><key>check</key><value>False</value></param>
<param><key>packed</key><value>True</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fcs</value></param>
<param><key>label</key><value>FCS</value></param>
<param><key>value</key><value>False</value></param>
</block>
<block>
<key>fec_extended_tagged_decoder</key>
<param><key>id</key><value>fec_extended_tagged_decoder_0_0</value></param>
<param><key>decoder_list</key><value>cc_decoder_PDU</value></param>
<param><key>lentagname</key><value>packet_len</value></param>
<param><key>mtu</key><value>phy.n_block*9</value></param>
<param><key>puncpat</key><value>'11'</value></param>
</block>
<block>
<key>fec_extended_tagged_encoder</key>
<param><key>id</key><value>fec_extended_tagged_encoder_0_0</value></param>
<param><key>encoder_list</key><value>cc_encoder_PDU</value></param>
<param><key>lentagname</key><value>len_tag_var</value></param>
<param><key>mtu</key><value>phy.n_block*9</value></param>
<param><key>puncpat</key><value>'11'</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy as np</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0</value></param>
<param><key>import</key><value>import pmt</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_1</value></param>
<param><key>import</key><value>import lpwan</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>index</value></param>
<param><key>label</key><value>Modulation index</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>lecim_fsk_signal_detector</key>
<param><key>id</key><value>lecim_fsk_signal_detector_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>preamble</key><value>phy.preamble_mod</value></param>
<param><key>sps</key><value>2</value></param>
<param><key>threshold</key><value>0.8</value></param>
</block>
<block>
<key>lecim_fsk_zero_padding</key>
<param><key>id</key><value>lecim_fsk_zero_padding_0_0</value></param>
<param><key>len_tag_var</key><value>"packet_len"</value></param>
<param><key>pad</key><value>phy.n_pad+6</value></param>
</block>
<block>
<key>lpwan_fsk_lecim_deinterleaver</key>
<param><key>id</key><value>lpwan_fsk_lecim_deinterleaver_0_0</value></param>
<param><key>len_tag</key><value>packet_len</value></param>
<param><key>nBlock</key><value>phy.n_block</value></param>
<param><key>phr</key><value>False</value></param>
</block>
<block>
<key>lpwan_fsk_lecim_demodulator_cb</key>
<param><key>id</key><value>lpwan_fsk_lecim_demodulator_cb_0</value></param>
<param><key>freq_dev</key><value>phy.freq_dev</value></param>
<param><key>pfsk</key><value>phy.PFSK</value></param>
<param><key>sps</key><value>phy.sps</value></param>
<param><key>symbol_rate</key><value>phy.symbol_rate</value></param>
</block>
<block>
<key>lpwan_fsk_lecim_despreading_bb</key>
<param><key>id</key><value>lpwan_fsk_lecim_despreading_bb_0_0</value></param>
<param><key>alternating</key><value>spreading_alternating</value></param>
<param><key>spreading</key><value>spreading</value></param>
<param><key>spreading_factor</key><value>spreading_factor</value></param>
</block>
<block>
<key>lpwan_fsk_lecim_freq_offset_est_cc</key>
<param><key>id</key><value>lpwan_fsk_lecim_freq_offset_est_cc_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>freq_dev</key><value>phy.freq_dev</value></param>
<param><key>preamble</key><value>phy.preamble_mod</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>symbol_rate</key><value>phy.symbol_rate</value></param>
</block>
<block>
<key>lpwan_fsk_lecim_interleaver</key>
<param><key>id</key><value>lpwan_fsk_lecim_interleaver_1_0</value></param>
<param><key>len_tag</key><value>packet_len</value></param>
<param><key>nBlock</key><value>phy.n_block</value></param>
<param><key>phr</key><value>False</value></param>
</block>
<block>
<key>lpwan_fsk_lecim_modulator_fc</key>
<param><key>id</key><value>lpwan_fsk_lecim_modulator_fc_0</value></param>
<param><key>freq_dev</key><value>phy.freq_dev</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>symbol_rate</key><value>phy.symbol_rate</value></param>
</block>
<block>
<key>lpwan_fsk_lecim_spreading_bb</key>
<param><key>id</key><value>lpwan_fsk_lecim_spreading_bb_0_0_0</value></param>
<param><key>alternating</key><value>phy.phyLecimFskSpreadingAlternating</value></param>
<param><key>spreading</key><value>phy.phyLecimFskSpreading</value></param>
<param><key>spreading_factor</key><value>phy.phyLecimFskSpreadingFactor</value></param>
</block>
<block>
<key>lpwan_fsk_lecim_whitening_bb</key>
<param><key>id</key><value>lpwan_fsk_lecim_whitening_bb_0</value></param>
<param><key>whitening</key><value>phy.data_whitening</value></param>
</block>
<block>
<key>lpwan_fsk_lecim_whitening_bb</key>
<param><key>id</key><value>lpwan_fsk_lecim_whitening_bb_0_0</value></param>
<param><key>whitening</key><value>phy.data_whitening</value></param>
</block>
<block>
<key>lpwan_fsk_lecim_zero_depadding_bb</key>
<param><key>id</key><value>lpwan_fsk_lecim_zero_depadding_bb_0</value></param>
</block>
<block>
<key>lpwan_message_counter</key>
<param><key>id</key><value>lpwan_message_counter_0_0_0_0</value></param>
<param><key>check</key><value>True</value></param>
<param><key>interval</key><value>0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>lpwan_message_counter</key>
<param><key>id</key><value>lpwan_message_counter_0_0_0_0_0</value></param>
<param><key>check</key><value>False</value></param>
<param><key>interval</key><value>0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>pdu_len</value></param>
<param><key>label</key><value>PDU Length</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>pfsk</value></param>
<param><key>label</key><value>Position based FSK</value></param>
<param><key>value</key><value>False</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>preamble_len</value></param>
<param><key>label</key><value>Preamble Length</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>64</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_0</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_NONE</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label1</key><value>SENT</value></param>
<param><key>label2</key><value>PHR</value></param>
<param><key>nconnections</key><value>2</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>size</key><value>1024*15</value></param>
<param><key>srate</key><value>samp_rate_1*sps</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>2000</value></param>
<param><key>ymin</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>resampling</value></param>
<param><key>label</key><value>resampling</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>spreading</value></param>
<param><key>label</key><value>Spreading</value></param>
<param><key>value</key><value>False</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>spreading_alternating</value></param>
<param><key>label</key><value>Spreading alternating</value></param>
<param><key>value</key><value>False</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>spreading_factor</value></param>
<param><key>label</key><value>Spreading factor</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>sps</value></param>
<param><key>label</key><value>Sample per symbol</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>2</value></param>
</block>
<connection><source_block_id>analog_random_source_x_0</source_block_id><sink_block_id>blocks_stream_mux_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_multiply_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_stream_mux_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_file_source_0_0</source_block_id><sink_block_id>blocks_stream_mux_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_1</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>lpwan_fsk_lecim_demodulator_cb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_or_xx_0</source_block_id><sink_block_id>blocks_or_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_or_xx_0_0</source_block_id><sink_block_id>lpwan_fsk_lecim_despreading_bb_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_1</source_block_id><sink_block_id>blocks_repack_bits_bb_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repack_bits_bb_0</source_block_id><sink_block_id>blocks_tagged_stream_to_pdu_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repack_bits_bb_0_0_0</source_block_id><sink_block_id>lecim_fsk_zero_padding_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_mux_0</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_mux_0_0</source_block_id><sink_block_id>blocks_xor_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0</source_block_id><sink_block_id>digital_crc32_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tag_gate_0</source_block_id><sink_block_id>digital_chunks_to_symbols_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_to_pdu_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>pdus</source_key><sink_key>print_pdu</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_to_pdu_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_1</sink_block_id><source_key>pdus</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_to_pdu_0</source_block_id><sink_block_id>lpwan_message_counter_0_0_0_0_0</sink_block_id><source_key>pdus</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_to_pdu_0_0</source_block_id><sink_block_id>blocks_message_debug_0_0</sink_block_id><source_key>pdus</source_key><sink_key>print_pdu</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_to_pdu_0_0</source_block_id><sink_block_id>digital_crc32_async_bb_1</sink_block_id><source_key>pdus</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0</source_block_id><sink_block_id>blocks_or_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0_0</source_block_id><sink_block_id>blocks_or_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_1</source_block_id><sink_block_id>blocks_stream_mux_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_xor_xx_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_chunks_to_symbols_xx_0_0</source_block_id><sink_block_id>lpwan_fsk_lecim_modulator_fc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_chunks_to_symbols_xx_0_0_0</source_block_id><sink_block_id>fec_extended_tagged_decoder_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_crc32_async_bb_1</source_block_id><sink_block_id>lpwan_message_counter_0_0_0_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>digital_crc32_bb_0</source_block_id><sink_block_id>blocks_tagged_stream_to_pdu_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fec_extended_tagged_decoder_0_0</source_block_id><sink_block_id>blocks_file_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fec_extended_tagged_decoder_0_0</source_block_id><sink_block_id>blocks_xor_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>fec_extended_tagged_decoder_0_0</source_block_id><sink_block_id>lpwan_fsk_lecim_zero_depadding_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fec_extended_tagged_encoder_0_0</source_block_id><sink_block_id>lpwan_fsk_lecim_interleaver_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lecim_fsk_signal_detector_0</source_block_id><sink_block_id>blocks_null_sink_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lecim_fsk_signal_detector_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lecim_fsk_signal_detector_0</source_block_id><sink_block_id>lpwan_fsk_lecim_freq_offset_est_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lecim_fsk_zero_padding_0_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lecim_fsk_zero_padding_0_0</source_block_id><sink_block_id>blocks_stream_mux_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lecim_fsk_zero_padding_0_0</source_block_id><sink_block_id>fec_extended_tagged_encoder_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_fsk_lecim_deinterleaver_0_0</source_block_id><sink_block_id>digital_chunks_to_symbols_xx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_fsk_lecim_demodulator_cb_0</source_block_id><sink_block_id>blocks_or_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>lpwan_fsk_lecim_despreading_bb_0_0</source_block_id><sink_block_id>lpwan_fsk_lecim_whitening_bb_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_fsk_lecim_freq_offset_est_cc_0</source_block_id><sink_block_id>blocks_null_sink_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_fsk_lecim_freq_offset_est_cc_0</source_block_id><sink_block_id>blocks_tag_debug_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_fsk_lecim_interleaver_1_0</source_block_id><sink_block_id>lpwan_fsk_lecim_whitening_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_fsk_lecim_modulator_fc_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_fsk_lecim_modulator_fc_0</source_block_id><sink_block_id>blocks_multiply_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>lpwan_fsk_lecim_spreading_bb_0_0_0</source_block_id><sink_block_id>blocks_tag_gate_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_fsk_lecim_whitening_bb_0</source_block_id><sink_block_id>lpwan_fsk_lecim_spreading_bb_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_fsk_lecim_whitening_bb_0_0</source_block_id><sink_block_id>lpwan_fsk_lecim_deinterleaver_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_fsk_lecim_zero_depadding_bb_0</source_block_id><sink_block_id>blocks_repack_bits_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_message_counter_0_0_0_0</source_block_id><sink_block_id>qtgui_number_sink_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>lpwan_message_counter_0_0_0_0_0</source_block_id><sink_block_id>qtgui_number_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
