<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_0</value></param>
<param><key>value</key><value>12500</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_1</value></param>
<param><key>value</key><value>25000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_2</value></param>
<param><key>value</key><value>37500</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_3</value></param>
<param><key>value</key><value>75000</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>digital_crc32_async_bb</key>
<param><key>id</key><value>digital_crc32_async_bb_1</value></param>
<param><key>check</key><value>True</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy as np</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>index</value></param>
<param><key>label</key><value>Modulation index</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>lpwan_lecim_fsk_phy_rx</key>
<param><key>id</key><value>lpwan_lecim_fsk_phy_rx_0</value></param>
<param><key>band</key><value>False</value></param>
<param><key>threshold_1</key><value>0.8</value></param>
<param><key>data_whitening</key><value>True</value></param>
<param><key>threshold_0</key><value>0.2</value></param>
<param><key>fcs</key><value>False</value></param>
<param><key>index</key><value>index</value></param>
<param><key>pdu_len</key><value>pdu_len +4</value></param>
<param><key>pfsk</key><value>False</value></param>
<param><key>preamble_len</key><value>64</value></param>
<param><key>resampling</key><value>resampling</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>spreading_alternating</key><value>False</value></param>
<param><key>spreading_factor</key><value>16</value></param>
<param><key>spreading</key><value>True</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>pdu_len</value></param>
<param><key>label</key><value>PDU Length</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>28</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>resampling</value></param>
<param><key>label</key><value>Resampling factor</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>sps</value></param>
<param><key>label</key><value>Sample per symbol</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>RX2</value></param>
<param><key>center_freq0</key><value>902200000</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>30</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate_1*sps*resampling</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>digital_crc32_async_bb_1</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>out</source_key><sink_key>print_pdu</sink_key></connection>
<connection><source_block_id>lpwan_lecim_fsk_phy_rx_0</source_block_id><sink_block_id>digital_crc32_async_bb_1</sink_block_id><source_key>out_rx</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>lpwan_lecim_fsk_phy_rx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
