<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>lpwan_lecim_fsk_phy_direct</value></param>
<param><key>author</key><value>Victor Guipont</value></param>
<param><key>category</key><value>[LPWAN]</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>LPWAN LECIM FSK PHY</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>PHR</value></param>
<param><key>value</key><value>phy.PHR</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>SHR</value></param>
<param><key>value</key><value>phy.SHR</value></param>
</block>
<block>
<key>variable_cc_decoder_def</key>
<param><key>id</key><value>cc_decoder_PDU</value></param>
<param><key>padding</key><value>False</value></param>
<param><key>k</key><value>7</value></param>
<param><key>state_end</key><value>-1</value></param>
<param><key>framebits</key><value>phy.n_block*9*8</value></param>
<param><key>ndim</key><value>0</value></param>
<param><key>polys</key><value>cc_poly</value></param>
<param><key>rate</key><value>2</value></param>
<param><key>state_start</key><value>0</value></param>
<param><key>mode</key><value>fec.CC_TERMINATED</value></param>
</block>
<block>
<key>variable_cc_decoder_def</key>
<param><key>id</key><value>cc_decoder_PHR</value></param>
<param><key>padding</key><value>True</value></param>
<param><key>k</key><value>7</value></param>
<param><key>state_end</key><value>-1</value></param>
<param><key>framebits</key><value>44</value></param>
<param><key>ndim</key><value>0</value></param>
<param><key>polys</key><value>cc_poly</value></param>
<param><key>rate</key><value>2</value></param>
<param><key>state_start</key><value>0</value></param>
<param><key>mode</key><value>fec.CC_TERMINATED</value></param>
</block>
<block>
<key>variable_cc_encoder_def</key>
<param><key>id</key><value>cc_encoder_PDU</value></param>
<param><key>padding</key><value>False</value></param>
<param><key>k</key><value>7</value></param>
<param><key>framebits</key><value>phy.n_block*9*8</value></param>
<param><key>ndim</key><value>0</value></param>
<param><key>polys</key><value>cc_poly</value></param>
<param><key>rate</key><value>2</value></param>
<param><key>state_start</key><value>0</value></param>
<param><key>mode</key><value>fec.CC_TERMINATED</value></param>
</block>
<block>
<key>variable_cc_encoder_def</key>
<param><key>id</key><value>cc_encoder_PHR</value></param>
<param><key>padding</key><value>False</value></param>
<param><key>k</key><value>7</value></param>
<param><key>framebits</key><value>16</value></param>
<param><key>ndim</key><value>0</value></param>
<param><key>polys</key><value>cc_poly</value></param>
<param><key>rate</key><value>2</value></param>
<param><key>state_start</key><value>0</value></param>
<param><key>mode</key><value>fec.CC_TERMINATED</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cc_poly</value></param>
<param><key>value</key><value>[121,91]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>len_tag_var</value></param>
<param><key>value</key><value>"packet_len"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>phy</value></param>
<param><key>value</key><value>lpwan.fsk_lecim_phy.physical_layer(sps, index, band, preamble_len, fcs, data_whitening, pfsk, spreading, spreading_alternating, spreading_factor, pdu_len)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>phy.symbol_rate*phy.sps</value></param>
</block>
<block>
<key>analog_random_source_x</key>
<param><key>id</key><value>analog_random_source_x_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>max</key><value>255</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_samps</key><value>pdu_len</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>band</value></param>
<param><key>label</key><value>Band 169Mhz</value></param>
<param><key>value</key><value>False</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0</value></param>
<param><key>delay</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/Users/victorguipont/Developpement-informatique/GNU-radio/source</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0</value></param>
<param><key>msg</key><value>pmt.intern("generate")</value></param>
<param><key>period</key><value>1000</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_random_pdu</key>
<param><key>id</key><value>blocks_random_pdu_0</value></param>
<param><key>mask</key><value>0xFF</value></param>
<param><key>length_modulo</key><value>1</value></param>
<param><key>maxsize</key><value>pdu_len</value></param>
<param><key>minsize</key><value>pdu_len</value></param>
</block>
<block>
<key>blocks_repack_bits_bb</key>
<param><key>id</key><value>blocks_repack_bits_bb_0</value></param>
<param><key>k</key><value>1</value></param>
<param><key>l</key><value>8</value></param>
<param><key>endianness</key><value>gr.GR_LSB_FIRST</value></param>
<param><key>len_tag_key</key><value>pdu_len</value></param>
</block>
<block>
<key>blocks_repack_bits_bb</key>
<param><key>id</key><value>blocks_repack_bits_bb_0_0</value></param>
<param><key>k</key><value>8</value></param>
<param><key>l</key><value>1</value></param>
<param><key>endianness</key><value>gr.GR_LSB_FIRST</value></param>
<param><key>len_tag_key</key><value>len_tag_var</value></param>
<param><key>align_output</key><value>True</value></param>
</block>
<block>
<key>blocks_stream_mux</key>
<param><key>id</key><value>blocks_stream_mux_0</value></param>
<param><key>lengths</key><value>len(SHR), (len(PHR)*2+12)*spreading_factor if phy.phyLecimFskSpreading else len(PHR)*2+12, phy.n_block*9*8*spreading_factor if phy.phyLecimFskSpreading else phy.n_block*9*8</value></param>
<param><key>num_inputs</key><value>3</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_stream_to_tagged_stream</key>
<param><key>id</key><value>blocks_stream_to_tagged_stream_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>len_tag_key</key><value>"packet_len"</value></param>
<param><key>packet_len</key><value>pdu_len</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_tagged_stream_to_pdu</key>
<param><key>id</key><value>blocks_tagged_stream_to_pdu_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>pdu_len</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>tags</key><value>[gr.tag_utils.python_to_tag((0, pmt.intern(len_tag_var), pmt.from_long(len(SHR))))]</value></param>
<param><key>vector</key><value>SHR</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_1</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>tags</key><value>[gr.tag_utils.python_to_tag((0, pmt.intern(len_tag_var), pmt.from_long(len(PHR))))]</value></param>
<param><key>vector</key><value>PHR</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>burst_tag</value></param>
<param><key>label</key><value>Burst Tag (for USRP)</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"burst"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>data_whitening</value></param>
<param><key>label</key><value>Data whitening</value></param>
<param><key>value</key><value>True</value></param>
</block>
<block>
<key>digital_chunks_to_symbols_xx</key>
<param><key>id</key><value>digital_chunks_to_symbols_xx_0_0</value></param>
<param><key>dimension</key><value>1</value></param>
<param><key>in_type</key><value>byte</value></param>
<param><key>out_type</key><value>float</value></param>
<param><key>symbol_table</key><value>-1,1</value></param>
</block>
<block>
<key>digital_chunks_to_symbols_xx</key>
<param><key>id</key><value>digital_chunks_to_symbols_xx_0_0_0</value></param>
<param><key>dimension</key><value>1</value></param>
<param><key>in_type</key><value>byte</value></param>
<param><key>out_type</key><value>float</value></param>
<param><key>symbol_table</key><value>-1,1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fcs</value></param>
<param><key>label</key><value>FCS</value></param>
<param><key>value</key><value>False</value></param>
</block>
<block>
<key>fec_extended_tagged_decoder</key>
<param><key>id</key><value>fec_extended_tagged_decoder_0</value></param>
<param><key>decoder_list</key><value>cc_decoder_PHR</value></param>
<param><key>lentagname</key><value>packet_len</value></param>
<param><key>mtu</key><value>6</value></param>
<param><key>puncpat</key><value>'11'</value></param>
</block>
<block>
<key>fec_extended_tagged_decoder</key>
<param><key>id</key><value>fec_extended_tagged_decoder_0_0</value></param>
<param><key>decoder_list</key><value>cc_decoder_PDU</value></param>
<param><key>lentagname</key><value>packet_len</value></param>
<param><key>mtu</key><value>phy.n_block*9</value></param>
<param><key>puncpat</key><value>'11'</value></param>
</block>
<block>
<key>fec_extended_tagged_encoder</key>
<param><key>id</key><value>fec_extended_tagged_encoder</value></param>
<param><key>encoder_list</key><value>cc_encoder_PHR</value></param>
<param><key>lentagname</key><value>len_tag_var</value></param>
<param><key>mtu</key><value>2</value></param>
<param><key>puncpat</key><value>'11'</value></param>
</block>
<block>
<key>fec_extended_tagged_encoder</key>
<param><key>id</key><value>fec_extended_tagged_encoder_0</value></param>
<param><key>encoder_list</key><value>cc_encoder_PDU</value></param>
<param><key>lentagname</key><value>len_tag_var</value></param>
<param><key>mtu</key><value>phy.n_block*9</value></param>
<param><key>puncpat</key><value>'11'</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import lpwan</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0</value></param>
<param><key>import</key><value>import random as rnd</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_1</value></param>
<param><key>import</key><value>import numpy as np</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_2</value></param>
<param><key>import</key><value>import pmt</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>index</value></param>
<param><key>label</key><value>Modulation index</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0.5</value></param>
</block>
<block>
<key>lecim_fsk_modulator</key>
<param><key>id</key><value>lecim_fsk_modulator_0</value></param>
<param><key>burst_tag</key><value>burst_tag</value></param>
<param><key>freq_dev</key><value>phy.freq_dev</value></param>
<param><key>packet_len</key><value>len(SHR)+(44+72*phy.n_block)*spreading_factor</value></param>
<param><key>pfsk</key><value>phy.PFSK</value></param>
<param><key>sps</key><value>phy.sps</value></param>
<param><key>symbol_rate</key><value>phy.symbol_rate</value></param>
</block>
<block>
<key>lecim_fsk_zero_padding</key>
<param><key>id</key><value>lecim_fsk_zero_padding_0</value></param>
<param><key>len_tag_var</key><value>"packet_len"</value></param>
<param><key>pad</key><value>phy.n_pad</value></param>
</block>
<block>
<key>lpwan_fsk_lecim_corr_est_cc</key>
<param><key>id</key><value>lpwan_fsk_lecim_corr_est_cc_0</value></param>
<param><key>pfsk</key><value>phy.PFSK</value></param>
<param><key>sps</key><value>phy.sps</value></param>
<param><key>symbols</key><value>phy.SHR_mod</value></param>
<param><key>mark_delay</key><value>1</value></param>
<param><key>threshold</key><value>0.999</value></param>
</block>
<block>
<key>lpwan_fsk_lecim_deinterleaver</key>
<param><key>id</key><value>lpwan_fsk_lecim_deinterleaver_0</value></param>
<param><key>len_tag</key><value>packet_len</value></param>
<param><key>nBlock</key><value>phy.n_block</value></param>
<param><key>phr</key><value>True</value></param>
</block>
<block>
<key>lpwan_fsk_lecim_deinterleaver</key>
<param><key>id</key><value>lpwan_fsk_lecim_deinterleaver_0_0</value></param>
<param><key>len_tag</key><value>packet_len</value></param>
<param><key>nBlock</key><value>phy.n_block</value></param>
<param><key>phr</key><value>False</value></param>
</block>
<block>
<key>lpwan_fsk_lecim_demodulator_cb</key>
<param><key>id</key><value>lpwan_fsk_lecim_demodulator_cb_0</value></param>
<param><key>freq_dev</key><value>phy.freq_dev</value></param>
<param><key>pfsk</key><value>phy.PFSK</value></param>
<param><key>sps</key><value>phy.sps</value></param>
<param><key>symbol_rate</key><value>phy.symbol_rate</value></param>
</block>
<block>
<key>lpwan_fsk_lecim_despreading_bb</key>
<param><key>id</key><value>lpwan_fsk_lecim_despreading_bb_1</value></param>
<param><key>alternating</key><value>phy.phyLecimFskSpreadingAlternating</value></param>
<param><key>spreading</key><value>phy.phyLecimFskSpreading</value></param>
<param><key>spreading_factor</key><value>phy.phyLecimFskSpreadingFactor</value></param>
</block>
<block>
<key>lpwan_fsk_lecim_despreading_bb</key>
<param><key>id</key><value>lpwan_fsk_lecim_despreading_bb_1_0</value></param>
<param><key>alternating</key><value>phy.phyLecimFskSpreadingAlternating</value></param>
<param><key>spreading</key><value>phy.phyLecimFskSpreading</value></param>
<param><key>spreading_factor</key><value>phy.phyLecimFskSpreadingFactor</value></param>
</block>
<block>
<key>lpwan_fsk_lecim_interleaver</key>
<param><key>id</key><value>lpwan_fsk_lecim_interleaver_0</value></param>
<param><key>len_tag</key><value>len_tag_var</value></param>
<param><key>nBlock</key><value>phy.n_block</value></param>
<param><key>phr</key><value>True</value></param>
</block>
<block>
<key>lpwan_fsk_lecim_interleaver</key>
<param><key>id</key><value>lpwan_fsk_lecim_interleaver_1</value></param>
<param><key>len_tag</key><value>packet_len</value></param>
<param><key>nBlock</key><value>phy.n_block</value></param>
<param><key>phr</key><value>False</value></param>
</block>
<block>
<key>lpwan_fsk_lecim_phr_parser</key>
<param><key>id</key><value>lpwan_fsk_lecim_phr_parser_0</value></param>
<param><key>len_tag_key</key><value>"packet_len"</value></param>
</block>
<block>
<key>lpwan_fsk_lecim_phr_pdu_demux</key>
<param><key>id</key><value>lpwan_fsk_lecim_phr_pdu_demux_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>output_symbols</key><value>True</value></param>
<param><key>sps</key><value>phy.sps</value></param>
<param><key>sf</key><value>phy.phyLecimFskSpreadingFactor</value></param>
<param><key>symbol_rate</key><value>phy.symbol_rate</value></param>
</block>
<block>
<key>lpwan_fsk_lecim_spreading_bb</key>
<param><key>id</key><value>lpwan_fsk_lecim_spreading_bb_0</value></param>
<param><key>alternating</key><value>phy.phyLecimFskSpreadingAlternating</value></param>
<param><key>spreading</key><value>phy.phyLecimFskSpreading</value></param>
<param><key>spreading_factor</key><value>phy.phyLecimFskSpreadingFactor</value></param>
</block>
<block>
<key>lpwan_fsk_lecim_spreading_bb</key>
<param><key>id</key><value>lpwan_fsk_lecim_spreading_bb_0_0</value></param>
<param><key>alternating</key><value>phy.phyLecimFskSpreadingAlternating</value></param>
<param><key>spreading</key><value>phy.phyLecimFskSpreading</value></param>
<param><key>spreading_factor</key><value>phy.phyLecimFskSpreadingFactor</value></param>
</block>
<block>
<key>lpwan_fsk_lecim_whitening_bb</key>
<param><key>id</key><value>lpwan_fsk_lecim_whitening_bb_0</value></param>
<param><key>whitening</key><value>phy.data_whitening</value></param>
</block>
<block>
<key>lpwan_fsk_lecim_whitening_bb</key>
<param><key>id</key><value>lpwan_fsk_lecim_whitening_bb_1</value></param>
<param><key>whitening</key><value>phy.data_whitening</value></param>
</block>
<block>
<key>lpwan_fsk_lecim_zero_depadding_bb</key>
<param><key>id</key><value>lpwan_fsk_lecim_zero_depadding_bb_0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>pdu_len</value></param>
<param><key>label</key><value>PDU Length</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>pfsk</value></param>
<param><key>label</key><value>Position based FSK</value></param>
<param><key>value</key><value>False</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>preamble_len</value></param>
<param><key>label</key><value>Preamble Length</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>64</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>size</key><value>1072*6</value></param>
<param><key>srate</key><value>phy.symbol_rate*phy.sps</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>spreading</value></param>
<param><key>label</key><value>Spreading</value></param>
<param><key>value</key><value>True</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>spreading_alternating</value></param>
<param><key>label</key><value>Spreading alternating</value></param>
<param><key>value</key><value>False</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>spreading_factor</value></param>
<param><key>label</key><value>Spreading factor</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>16</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>sps</value></param>
<param><key>label</key><value>Sample per symbol</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0</value></param>
<param><key>stream_id</key><value>PDU</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_1</value></param>
<param><key>stream_id</key><value>PHR</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_2</value></param>
<param><key>stream_id</key><value>mod_data</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_2_0</value></param>
<param><key>stream_id</key><value>phr_info</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_3</value></param>
<param><key>stream_id</key><value>phr_mod</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_3_0</value></param>
<param><key>stream_id</key><value>pdu_mod</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0</value></param>
<param><key>stream_id</key><value>PHR</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1</value></param>
<param><key>stream_id</key><value>PDU</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_2</value></param>
<param><key>stream_id</key><value>mod_data</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_2_0</value></param>
<param><key>stream_id</key><value>phr_info</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_3</value></param>
<param><key>stream_id</key><value>phr_mod</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_3_0</value></param>
<param><key>stream_id</key><value>pdu_mod</value></param>
</block>
<connection><source_block_id>analog_random_source_x_0</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>virtual_sink_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_0</source_block_id><sink_block_id>blocks_random_pdu_0</sink_block_id><source_key>strobe</source_key><sink_key>generate</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0</source_block_id><sink_block_id>blocks_repack_bits_bb_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_random_pdu_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0</sink_block_id><source_key>pdus</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>blocks_repack_bits_bb_0</source_block_id><sink_block_id>blocks_tagged_stream_to_pdu_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repack_bits_bb_0_0</source_block_id><sink_block_id>lecim_fsk_zero_padding_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_mux_0</source_block_id><sink_block_id>lecim_fsk_modulator_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0</source_block_id><sink_block_id>blocks_repack_bits_bb_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_to_pdu_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>pdus</source_key><sink_key>print_pdu</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_delay_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0</source_block_id><sink_block_id>blocks_stream_mux_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_1</source_block_id><sink_block_id>fec_extended_tagged_encoder</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_chunks_to_symbols_xx_0_0</source_block_id><sink_block_id>fec_extended_tagged_decoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_chunks_to_symbols_xx_0_0_0</source_block_id><sink_block_id>fec_extended_tagged_decoder_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fec_extended_tagged_decoder_0</source_block_id><sink_block_id>lpwan_fsk_lecim_phr_parser_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fec_extended_tagged_decoder_0_0</source_block_id><sink_block_id>lpwan_fsk_lecim_zero_depadding_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fec_extended_tagged_encoder</source_block_id><sink_block_id>lpwan_fsk_lecim_interleaver_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fec_extended_tagged_encoder_0</source_block_id><sink_block_id>lpwan_fsk_lecim_interleaver_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lecim_fsk_modulator_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lecim_fsk_zero_padding_0</source_block_id><sink_block_id>fec_extended_tagged_encoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_fsk_lecim_corr_est_cc_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_fsk_lecim_corr_est_cc_0</source_block_id><sink_block_id>lpwan_fsk_lecim_demodulator_cb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_fsk_lecim_deinterleaver_0</source_block_id><sink_block_id>digital_chunks_to_symbols_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_fsk_lecim_deinterleaver_0_0</source_block_id><sink_block_id>digital_chunks_to_symbols_xx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_fsk_lecim_demodulator_cb_0</source_block_id><sink_block_id>lpwan_fsk_lecim_phr_pdu_demux_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_fsk_lecim_despreading_bb_1</source_block_id><sink_block_id>lpwan_fsk_lecim_deinterleaver_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_fsk_lecim_despreading_bb_1_0</source_block_id><sink_block_id>lpwan_fsk_lecim_whitening_bb_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_fsk_lecim_interleaver_0</source_block_id><sink_block_id>lpwan_fsk_lecim_spreading_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_fsk_lecim_interleaver_1</source_block_id><sink_block_id>lpwan_fsk_lecim_whitening_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_fsk_lecim_phr_parser_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>phr_data</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>lpwan_fsk_lecim_phr_parser_0</source_block_id><sink_block_id>virtual_sink_2_0</sink_block_id><source_key>phr_data</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>lpwan_fsk_lecim_phr_pdu_demux_0</source_block_id><sink_block_id>virtual_sink_3_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_fsk_lecim_phr_pdu_demux_0</source_block_id><sink_block_id>virtual_sink_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_fsk_lecim_spreading_bb_0</source_block_id><sink_block_id>virtual_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_fsk_lecim_spreading_bb_0_0</source_block_id><sink_block_id>virtual_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_fsk_lecim_whitening_bb_0</source_block_id><sink_block_id>lpwan_fsk_lecim_spreading_bb_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_fsk_lecim_whitening_bb_1</source_block_id><sink_block_id>lpwan_fsk_lecim_deinterleaver_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_fsk_lecim_zero_depadding_bb_0</source_block_id><sink_block_id>blocks_repack_bits_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>blocks_stream_mux_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>virtual_source_1</source_block_id><sink_block_id>blocks_stream_mux_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>virtual_source_2</source_block_id><sink_block_id>lpwan_fsk_lecim_corr_est_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_2_0</source_block_id><sink_block_id>lpwan_fsk_lecim_phr_pdu_demux_0</sink_block_id><source_key>out</source_key><sink_key>phr_data</sink_key></connection>
<connection><source_block_id>virtual_source_3</source_block_id><sink_block_id>lpwan_fsk_lecim_despreading_bb_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_3_0</source_block_id><sink_block_id>lpwan_fsk_lecim_despreading_bb_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
