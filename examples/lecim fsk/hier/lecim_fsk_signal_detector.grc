<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>lecim_fsk_signal_detector</value></param>
<param><key>category</key><value>[LPWAN]</value></param>
<param><key>generate_options</key><value>hb</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_inputs</key><value>5</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0</value></param>
<param><key>delay</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0_0</value></param>
<param><key>delay</key><value>1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0_1</value></param>
<param><key>delay</key><value>2</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0_1_0</value></param>
<param><key>delay</key><value>3</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0_1_0_0</value></param>
<param><key>delay</key><value>4</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_1</value></param>
<param><key>delay</key><value>2*len(preamble)-4</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_tag_gate</key>
<param><key>id</key><value>blocks_tag_gate_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>propagate_tags</key><value>False</value></param>
</block>
<block>
<key>lpwan_conj_multiply_delay_ccc</key>
<param><key>id</key><value>lpwan_conj_multiply_delay_ccc_0</value></param>
<param><key>delay</key><value>1</value></param>
</block>
<block>
<key>lpwan_conj_multiply_delay_ccc</key>
<param><key>id</key><value>lpwan_conj_multiply_delay_ccc_0_1</value></param>
<param><key>delay</key><value>2</value></param>
</block>
<block>
<key>lpwan_conj_multiply_delay_ccc</key>
<param><key>id</key><value>lpwan_conj_multiply_delay_ccc_0_2</value></param>
<param><key>delay</key><value>3</value></param>
</block>
<block>
<key>lpwan_conj_multiply_delay_ccc</key>
<param><key>id</key><value>lpwan_conj_multiply_delay_ccc_0_2_0</value></param>
<param><key>delay</key><value>4</value></param>
</block>
<block>
<key>lpwan_conj_multiply_delay_ccc</key>
<param><key>id</key><value>lpwan_conj_multiply_delay_ccc_0_2_0_0</value></param>
<param><key>delay</key><value>5</value></param>
</block>
<block>
<key>lpwan_fsk_lecim_correlation_filter</key>
<param><key>id</key><value>lpwan_fsk_lecim_correlation_filter_0</value></param>
<param><key>delay</key><value>1</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>preamble</key><value>preamble</value></param>
</block>
<block>
<key>lpwan_fsk_lecim_correlation_filter</key>
<param><key>id</key><value>lpwan_fsk_lecim_correlation_filter_0_0</value></param>
<param><key>delay</key><value>3</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>preamble</key><value>preamble</value></param>
</block>
<block>
<key>lpwan_fsk_lecim_correlation_filter</key>
<param><key>id</key><value>lpwan_fsk_lecim_correlation_filter_0_0_0</value></param>
<param><key>delay</key><value>4</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>preamble</key><value>preamble</value></param>
</block>
<block>
<key>lpwan_fsk_lecim_correlation_filter</key>
<param><key>id</key><value>lpwan_fsk_lecim_correlation_filter_0_0_0_0</value></param>
<param><key>delay</key><value>5</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>preamble</key><value>preamble</value></param>
</block>
<block>
<key>lpwan_fsk_lecim_correlation_filter</key>
<param><key>id</key><value>lpwan_fsk_lecim_correlation_filter_0_1</value></param>
<param><key>delay</key><value>2</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>preamble</key><value>preamble</value></param>
</block>
<block>
<key>lpwan_fsk_lecim_detector</key>
<param><key>id</key><value>lpwan_fsk_lecim_detector_0</value></param>
<param><key>delay</key><value>5</value></param>
<param><key>len_preamble</key><value>len(preamble)</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>threshold</key><value>threshold</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>out</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label</key><value>double_corr</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_1</value></param>
<param><key>label</key><value>in_rx</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>preamble</value></param>
<param><key>label</key><value>Preamble</value></param>
<param><key>value</key><value>[1]</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>sps</value></param>
<param><key>label</key><value>Sample per symbol</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>threshold</value></param>
<param><key>label</key><value>Threshold</value></param>
<param><key>value</key><value>0.8</value></param>
</block>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>blocks_tag_gate_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>pad_sink_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_delay_0_1</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_delay_0_1_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>blocks_delay_0_1_0_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>blocks_delay_1</source_block_id><sink_block_id>lpwan_fsk_lecim_detector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tag_gate_0_0</source_block_id><sink_block_id>lpwan_fsk_lecim_detector_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>lpwan_conj_multiply_delay_ccc_0</source_block_id><sink_block_id>lpwan_fsk_lecim_correlation_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_conj_multiply_delay_ccc_0_1</source_block_id><sink_block_id>lpwan_fsk_lecim_correlation_filter_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_conj_multiply_delay_ccc_0_2</source_block_id><sink_block_id>lpwan_fsk_lecim_correlation_filter_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_conj_multiply_delay_ccc_0_2_0</source_block_id><sink_block_id>lpwan_fsk_lecim_correlation_filter_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_conj_multiply_delay_ccc_0_2_0_0</source_block_id><sink_block_id>lpwan_fsk_lecim_correlation_filter_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_fsk_lecim_correlation_filter_0</source_block_id><sink_block_id>blocks_delay_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_fsk_lecim_correlation_filter_0_0</source_block_id><sink_block_id>blocks_delay_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_fsk_lecim_correlation_filter_0_0_0</source_block_id><sink_block_id>blocks_delay_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_fsk_lecim_correlation_filter_0_0_0_0</source_block_id><sink_block_id>blocks_delay_0_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_fsk_lecim_correlation_filter_0_1</source_block_id><sink_block_id>blocks_delay_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_fsk_lecim_detector_0</source_block_id><sink_block_id>pad_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_1</source_block_id><sink_block_id>blocks_delay_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_1</source_block_id><sink_block_id>lpwan_conj_multiply_delay_ccc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_1</source_block_id><sink_block_id>lpwan_conj_multiply_delay_ccc_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_1</source_block_id><sink_block_id>lpwan_conj_multiply_delay_ccc_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_1</source_block_id><sink_block_id>lpwan_conj_multiply_delay_ccc_0_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_1</source_block_id><sink_block_id>lpwan_conj_multiply_delay_ccc_0_2_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
