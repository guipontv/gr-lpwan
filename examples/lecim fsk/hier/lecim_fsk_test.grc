<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>lpwan_lecim_fsk_test</value></param>
<param><key>category</key><value>[LPWAN]</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>TEST</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>phy</value></param>
<param><key>value</key><value>lpwan.fsk_lecim_phy.physical_layer(sps, 0.5, False, 64, False, True, pfsk, True, False, 16, 32)</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import lpwan</value></param>
</block>
<block>
<key>lecim_fsk_normalizer</key>
<param><key>id</key><value>lecim_fsk_normalizer_0</value></param>
<param><key>len_est</key><value>100</value></param>
</block>
<block>
<key>lpwan_fsk_lecim_detector_cc</key>
<param><key>id</key><value>lpwan_fsk_lecim_detector_cc_0</value></param>
<param><key>preamble</key><value>phy.preamble_mod</value></param>
<param><key>sps</key><value>phy.sps</value></param>
<param><key>threshold</key><value>threshold_0</value></param>
</block>
<block>
<key>lpwan_fsk_lecim_freq_offset_est_cc</key>
<param><key>id</key><value>lpwan_fsk_lecim_freq_offset_est_cc_0</value></param>
<param><key>freq_dev</key><value>phy.freq_dev</value></param>
<param><key>preamble</key><value>phy.preamble_mod</value></param>
<param><key>sps</key><value>phy.sps</value></param>
<param><key>symbol_rate</key><value>phy.symbol_rate</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>out</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>out_detector</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_1</value></param>
<param><key>label</key><value>in_rx</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>pfsk</value></param>
<param><key>label</key><value>Position based FSK</value></param>
<param><key>value</key><value>False</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>decim</key><value>resampling</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>taps</key><value>1</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>resampling</value></param>
<param><key>label</key><value>Resampling factor</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>sps</value></param>
<param><key>label</key><value>Sample per symbol</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>threshold_0</value></param>
<param><key>label</key><value>Detection threshold 1</value></param>
<param><key>value</key><value>0.95</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>threshold_1</value></param>
<param><key>label</key><value>Detection threshold 2</value></param>
<param><key>value</key><value>0.95</value></param>
</block>
<connection><source_block_id>lecim_fsk_normalizer_0</source_block_id><sink_block_id>lpwan_fsk_lecim_detector_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_fsk_lecim_detector_cc_0</source_block_id><sink_block_id>lpwan_fsk_lecim_freq_offset_est_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_fsk_lecim_detector_cc_0</source_block_id><sink_block_id>pad_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_fsk_lecim_freq_offset_est_cc_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_1</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>lecim_fsk_normalizer_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
