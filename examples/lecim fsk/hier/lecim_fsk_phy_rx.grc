<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>lpwan_lecim_fsk_phy_rx</value></param>
<param><key>author</key><value>Victor Guipont</value></param>
<param><key>category</key><value>[LPWAN]</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>LPWAN LECIM FSK PHY Rx</value></param>
</block>
<block>
<key>variable_cc_decoder_def</key>
<param><key>id</key><value>cc_decoder_PDU</value></param>
<param><key>padding</key><value>False</value></param>
<param><key>k</key><value>7</value></param>
<param><key>state_end</key><value>-1</value></param>
<param><key>framebits</key><value>phy.n_block*9*8</value></param>
<param><key>ndim</key><value>0</value></param>
<param><key>polys</key><value>cc_poly</value></param>
<param><key>rate</key><value>2</value></param>
<param><key>state_start</key><value>0</value></param>
<param><key>mode</key><value>fec.CC_TERMINATED</value></param>
</block>
<block>
<key>variable_cc_decoder_def</key>
<param><key>id</key><value>cc_decoder_PHR</value></param>
<param><key>padding</key><value>True</value></param>
<param><key>k</key><value>7</value></param>
<param><key>state_end</key><value>-1</value></param>
<param><key>framebits</key><value>44</value></param>
<param><key>ndim</key><value>0</value></param>
<param><key>polys</key><value>cc_poly</value></param>
<param><key>rate</key><value>2</value></param>
<param><key>state_start</key><value>0</value></param>
<param><key>mode</key><value>fec.CC_TERMINATED</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cc_poly</value></param>
<param><key>value</key><value>[121,91]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>len_tag_var</value></param>
<param><key>value</key><value>"packet_len"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>phy</value></param>
<param><key>value</key><value>lpwan.fsk_lecim_phy.physical_layer(sps, index, band, preamble_len, fcs, data_whitening, pfsk, spreading, spreading_alternating, spreading_factor, pdu_len)</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>band</value></param>
<param><key>label</key><value>Band 169Mhz</value></param>
<param><key>value</key><value>False</value></param>
</block>
<block>
<key>blocks_repack_bits_bb</key>
<param><key>id</key><value>blocks_repack_bits_bb_0</value></param>
<param><key>k</key><value>1</value></param>
<param><key>l</key><value>8</value></param>
<param><key>endianness</key><value>gr.GR_LSB_FIRST</value></param>
<param><key>len_tag_key</key><value>pdu_len</value></param>
</block>
<block>
<key>blocks_tag_debug</key>
<param><key>id</key><value>blocks_tag_debug_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>filter</key><value></value></param>
<param><key>name</key><value>PHR start</value></param>
</block>
<block>
<key>blocks_tag_debug</key>
<param><key>id</key><value>blocks_tag_debug_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>filter</key><value></value></param>
<param><key>name</key><value>Signal</value></param>
</block>
<block>
<key>blocks_tagged_stream_to_pdu</key>
<param><key>id</key><value>blocks_tagged_stream_to_pdu_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>pdu_len</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>data_whitening</value></param>
<param><key>label</key><value>Data whitening</value></param>
<param><key>value</key><value>False</value></param>
</block>
<block>
<key>digital_chunks_to_symbols_xx</key>
<param><key>id</key><value>digital_chunks_to_symbols_xx_0_0</value></param>
<param><key>dimension</key><value>1</value></param>
<param><key>in_type</key><value>byte</value></param>
<param><key>out_type</key><value>float</value></param>
<param><key>symbol_table</key><value>-1,1</value></param>
</block>
<block>
<key>digital_chunks_to_symbols_xx</key>
<param><key>id</key><value>digital_chunks_to_symbols_xx_0_0_0</value></param>
<param><key>dimension</key><value>1</value></param>
<param><key>in_type</key><value>byte</value></param>
<param><key>out_type</key><value>float</value></param>
<param><key>symbol_table</key><value>-1,1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fcs</value></param>
<param><key>label</key><value>FCS</value></param>
<param><key>value</key><value>False</value></param>
</block>
<block>
<key>fec_extended_tagged_decoder</key>
<param><key>id</key><value>fec_extended_tagged_decoder_0</value></param>
<param><key>decoder_list</key><value>cc_decoder_PHR</value></param>
<param><key>lentagname</key><value>packet_len</value></param>
<param><key>mtu</key><value>6</value></param>
<param><key>puncpat</key><value>'11'</value></param>
</block>
<block>
<key>fec_extended_tagged_decoder</key>
<param><key>id</key><value>fec_extended_tagged_decoder_0_0</value></param>
<param><key>decoder_list</key><value>cc_decoder_PDU</value></param>
<param><key>lentagname</key><value>packet_len</value></param>
<param><key>mtu</key><value>phy.n_block*9</value></param>
<param><key>puncpat</key><value>'11'</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import lpwan</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>index</value></param>
<param><key>label</key><value>Modulation index</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0.5</value></param>
</block>
<block>
<key>lecim_fsk_normalizer</key>
<param><key>id</key><value>lecim_fsk_normalizer_0</value></param>
<param><key>len_est</key><value>100</value></param>
</block>
<block>
<key>lpwan_conj_multiply_delay_ccc</key>
<param><key>id</key><value>lpwan_conj_multiply_delay_ccc_0</value></param>
<param><key>delay</key><value>1</value></param>
</block>
<block>
<key>lpwan_conj_multiply_delay_ccc</key>
<param><key>id</key><value>lpwan_conj_multiply_delay_ccc_0_0</value></param>
<param><key>delay</key><value>2</value></param>
</block>
<block>
<key>lpwan_conj_multiply_delay_ccc</key>
<param><key>id</key><value>lpwan_conj_multiply_delay_ccc_0_0_0</value></param>
<param><key>delay</key><value>3</value></param>
</block>
<block>
<key>lpwan_fsk_lecim_corr_est_cc</key>
<param><key>id</key><value>lpwan_fsk_lecim_corr_est_cc_0</value></param>
<param><key>sps</key><value>phy.sps</value></param>
<param><key>symbols</key><value>phy.SFD_mod</value></param>
<param><key>mark_delay</key><value>0</value></param>
<param><key>threshold</key><value>threshold_1</value></param>
</block>
<block>
<key>lpwan_fsk_lecim_deinterleaver</key>
<param><key>id</key><value>lpwan_fsk_lecim_deinterleaver_0</value></param>
<param><key>len_tag</key><value>packet_len</value></param>
<param><key>nBlock</key><value>phy.n_block</value></param>
<param><key>phr</key><value>True</value></param>
</block>
<block>
<key>lpwan_fsk_lecim_deinterleaver</key>
<param><key>id</key><value>lpwan_fsk_lecim_deinterleaver_0_0</value></param>
<param><key>len_tag</key><value>packet_len</value></param>
<param><key>nBlock</key><value>phy.n_block</value></param>
<param><key>phr</key><value>False</value></param>
</block>
<block>
<key>lpwan_fsk_lecim_demodulator_cb</key>
<param><key>id</key><value>lpwan_fsk_lecim_demodulator_cb_0</value></param>
<param><key>freq_dev</key><value>phy.freq_dev</value></param>
<param><key>pfsk</key><value>phy.PFSK</value></param>
<param><key>sps</key><value>phy.sps</value></param>
<param><key>symbol_rate</key><value>phy.symbol_rate</value></param>
</block>
<block>
<key>lpwan_fsk_lecim_despreading_bb</key>
<param><key>id</key><value>lpwan_fsk_lecim_despreading_bb_0</value></param>
<param><key>alternating</key><value>spreading_alternating</value></param>
<param><key>spreading</key><value>spreading</value></param>
<param><key>spreading_factor</key><value>spreading_factor</value></param>
</block>
<block>
<key>lpwan_fsk_lecim_despreading_bb</key>
<param><key>id</key><value>lpwan_fsk_lecim_despreading_bb_0_0</value></param>
<param><key>alternating</key><value>spreading_alternating</value></param>
<param><key>spreading</key><value>spreading</value></param>
<param><key>spreading_factor</key><value>spreading_factor</value></param>
</block>
<block>
<key>lpwan_fsk_lecim_freq_offset_est_cc</key>
<param><key>id</key><value>lpwan_fsk_lecim_freq_offset_est_cc_0</value></param>
<param><key>freq_dev</key><value>phy.freq_dev</value></param>
<param><key>preamble</key><value>phy.preamble_mod</value></param>
<param><key>sps</key><value>phy.sps</value></param>
<param><key>symbol_rate</key><value>phy.symbol_rate</value></param>
</block>
<block>
<key>lpwan_fsk_lecim_phr_parser</key>
<param><key>id</key><value>lpwan_fsk_lecim_phr_parser_0</value></param>
<param><key>len_tag_key</key><value>"packet_len"</value></param>
</block>
<block>
<key>lpwan_fsk_lecim_phr_pdu_demux</key>
<param><key>id</key><value>lpwan_fsk_lecim_phr_pdu_demux_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>output_symbols</key><value>True</value></param>
<param><key>sps</key><value>phy.sps</value></param>
<param><key>sf</key><value>phy.phyLecimFskSpreadingFactor</value></param>
<param><key>symbol_rate</key><value>phy.symbol_rate</value></param>
</block>
<block>
<key>lpwan_fsk_lecim_synchronizer_cc</key>
<param><key>id</key><value>lpwan_fsk_lecim_synchronizer_cc_0</value></param>
<param><key>sps</key><value>phy.sps</value></param>
<param><key>threshold</key><value>threshold_0</value></param>
<param><key>preamble</key><value>phy.preamble_mod</value></param>
</block>
<block>
<key>lpwan_fsk_lecim_whitening_bb</key>
<param><key>id</key><value>lpwan_fsk_lecim_whitening_bb_0</value></param>
<param><key>whitening</key><value>phy.data_whitening</value></param>
</block>
<block>
<key>lpwan_fsk_lecim_zero_depadding_bb</key>
<param><key>id</key><value>lpwan_fsk_lecim_zero_depadding_bb_0</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>message</value></param>
<param><key>label</key><value>phr_debug</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_1</value></param>
<param><key>type</key><value>message</value></param>
<param><key>label</key><value>out_rx</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_2</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>corr</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_2_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>double_corr</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_2_1_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>signal</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_2_1_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>signal_norm</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_1</value></param>
<param><key>label</key><value>in_rx</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>pdu_len</value></param>
<param><key>label</key><value>PDU Length</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>pfsk</value></param>
<param><key>label</key><value>Position based FSK</value></param>
<param><key>value</key><value>False</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>preamble_len</value></param>
<param><key>label</key><value>Preamble Length</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>64</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0_0</value></param>
<param><key>decim</key><value>resampling</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>resampling</value></param>
<param><key>label</key><value>Resampling factor</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>spreading</value></param>
<param><key>label</key><value>Spreading</value></param>
<param><key>value</key><value>True</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>spreading_alternating</value></param>
<param><key>label</key><value>Spreading alternating</value></param>
<param><key>value</key><value>False</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>spreading_factor</value></param>
<param><key>label</key><value>Spreading factor</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>sps</value></param>
<param><key>label</key><value>Sample per symbol</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>20</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>threshold_0</value></param>
<param><key>label</key><value>Detection threshold</value></param>
<param><key>value</key><value>0.95</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>threshold_1</value></param>
<param><key>label</key><value>Corr threshold</value></param>
<param><key>value</key><value>0.95</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_2_0</value></param>
<param><key>stream_id</key><value>phr_info</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_3_0_0</value></param>
<param><key>stream_id</key><value>pdu_mod</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_3_1</value></param>
<param><key>stream_id</key><value>phr_mod</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_2_0_0</value></param>
<param><key>stream_id</key><value>phr_info</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_3</value></param>
<param><key>stream_id</key><value>phr_mod</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_3_0</value></param>
<param><key>stream_id</key><value>pdu_mod</value></param>
</block>
<connection><source_block_id>blocks_repack_bits_bb_0</source_block_id><sink_block_id>blocks_tagged_stream_to_pdu_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_to_pdu_0</source_block_id><sink_block_id>pad_sink_1</sink_block_id><source_key>pdus</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>digital_chunks_to_symbols_xx_0_0</source_block_id><sink_block_id>fec_extended_tagged_decoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_chunks_to_symbols_xx_0_0_0</source_block_id><sink_block_id>fec_extended_tagged_decoder_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fec_extended_tagged_decoder_0</source_block_id><sink_block_id>lpwan_fsk_lecim_phr_parser_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fec_extended_tagged_decoder_0_0</source_block_id><sink_block_id>lpwan_fsk_lecim_zero_depadding_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lecim_fsk_normalizer_0</source_block_id><sink_block_id>lpwan_conj_multiply_delay_ccc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lecim_fsk_normalizer_0</source_block_id><sink_block_id>lpwan_conj_multiply_delay_ccc_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lecim_fsk_normalizer_0</source_block_id><sink_block_id>lpwan_conj_multiply_delay_ccc_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lecim_fsk_normalizer_0</source_block_id><sink_block_id>lpwan_fsk_lecim_synchronizer_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lecim_fsk_normalizer_0</source_block_id><sink_block_id>pad_sink_2_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_conj_multiply_delay_ccc_0</source_block_id><sink_block_id>lpwan_fsk_lecim_synchronizer_cc_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>lpwan_conj_multiply_delay_ccc_0_0</source_block_id><sink_block_id>lpwan_fsk_lecim_synchronizer_cc_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>lpwan_conj_multiply_delay_ccc_0_0_0</source_block_id><sink_block_id>lpwan_fsk_lecim_synchronizer_cc_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>lpwan_fsk_lecim_corr_est_cc_0</source_block_id><sink_block_id>pad_sink_2</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_fsk_lecim_corr_est_cc_0</source_block_id><sink_block_id>blocks_tag_debug_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_fsk_lecim_corr_est_cc_0</source_block_id><sink_block_id>lpwan_fsk_lecim_demodulator_cb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_fsk_lecim_deinterleaver_0</source_block_id><sink_block_id>digital_chunks_to_symbols_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_fsk_lecim_deinterleaver_0_0</source_block_id><sink_block_id>digital_chunks_to_symbols_xx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_fsk_lecim_demodulator_cb_0</source_block_id><sink_block_id>lpwan_fsk_lecim_phr_pdu_demux_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_fsk_lecim_despreading_bb_0</source_block_id><sink_block_id>lpwan_fsk_lecim_deinterleaver_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_fsk_lecim_despreading_bb_0_0</source_block_id><sink_block_id>lpwan_fsk_lecim_whitening_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_fsk_lecim_freq_offset_est_cc_0</source_block_id><sink_block_id>lpwan_fsk_lecim_corr_est_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_fsk_lecim_phr_parser_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>phr_data</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>lpwan_fsk_lecim_phr_parser_0</source_block_id><sink_block_id>virtual_sink_2_0</sink_block_id><source_key>phr_data</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>lpwan_fsk_lecim_phr_pdu_demux_0_0</source_block_id><sink_block_id>virtual_sink_3_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_fsk_lecim_phr_pdu_demux_0_0</source_block_id><sink_block_id>virtual_sink_3_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_fsk_lecim_synchronizer_cc_0</source_block_id><sink_block_id>pad_sink_2_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_fsk_lecim_synchronizer_cc_0</source_block_id><sink_block_id>blocks_tag_debug_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_fsk_lecim_synchronizer_cc_0</source_block_id><sink_block_id>lpwan_fsk_lecim_freq_offset_est_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_fsk_lecim_whitening_bb_0</source_block_id><sink_block_id>lpwan_fsk_lecim_deinterleaver_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_fsk_lecim_zero_depadding_bb_0</source_block_id><sink_block_id>blocks_repack_bits_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_1</source_block_id><sink_block_id>rational_resampler_xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0_0</source_block_id><sink_block_id>lecim_fsk_normalizer_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0_0</source_block_id><sink_block_id>pad_sink_2_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_2_0_0</source_block_id><sink_block_id>lpwan_fsk_lecim_phr_pdu_demux_0_0</sink_block_id><source_key>out</source_key><sink_key>phr_data</sink_key></connection>
<connection><source_block_id>virtual_source_3</source_block_id><sink_block_id>lpwan_fsk_lecim_despreading_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_3_0</source_block_id><sink_block_id>lpwan_fsk_lecim_despreading_bb_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
